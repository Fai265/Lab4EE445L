# Keil uVision project getWeather.uvproj, settings and files
target getWeather (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: getWeather
  AfterMake: fromelf --bin --output .\rvmdk\cc31000_starter.bin .\rvmdk\cc31000_starter.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM _POSIX_SOURCE UART_BUFFERED TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\;..\..\..\..;..\cc3100;..\cc3100\platform\ek-tm4c123gxl;..\cc3100\simplelink\include;..\cc3100\simplelink\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: cc31000_starter.sct
  link misc: --entry Reset_Handler
  group Source
    ./: main.c Nokia5110.c LED.c startup_rvmdk.S
    ../cc3100/platform/ek-tm4c123gxl/: board.c spi.c uart.c
    ../cc3100/simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
    ../utils/: uartstdio.c ustdlib.c
    ../SysTick_4C123/: SysTick.c
    ../ClockScreen/: ClockScreen.h ClockScreen.c
    ../ST7735_4C123/: ST7735.c ST7735.h
    ../Time/: Time.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
